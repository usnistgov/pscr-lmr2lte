options:
  parameters:
    generate_options: qt_gui
    id: NBFM_xcvr_1chan
    output_language: python
    realtime_scheduling: '1'
    title: Narrowband Single Channel FM Transceiver
  states: {}

blocks:
- name: DL_freq
  id: variable
  parameters:
    value: 162.075e6
  states: {}
- name: SDR_address
  id: variable
  parameters:
    value: '"type=b200"'
  states: {}
- name: SIPpw
  id: variable
  parameters:
    value: '"proxy-client-A"'
  states: {}
- name: SIPuri
  id: variable
  parameters:
    value: '"sip:mcptt_id_clientB@mcptt01.pscr.lz"'
  states: {}
- name: SIPuser
  id: variable
  parameters:
    value: '"proxy-client-A"'
  states: {}
- name: UL_freq
  id: variable
  parameters:
    value: 158.7525e6
  states: {}
- name: audio_samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: ctcss
  id: variable
  parameters:
    value: '179.9'
  states: {}
- name: gain
  id: variable
  parameters:
    comment: |-
      Don't set 
      less than 6
    value: '10'
  states: {}
- name: max_deviation
  id: variable
  parameters:
    value: '2500'
  states: {}
- name: samp_ratio
  id: variable
  parameters:
    value: '21'
  states: {}
- name: squelch
  id: variable_qtgui_range
  parameters:
    gui_hint: qtgui_tab_widget_0@1:0,0,1,2
    label: Power Squelch
    min_len: '100'
    orient: Qt.Horizontal
    start: '-100'
    step: '1'
    stop: '-20'
    value: '-80'
  states: {}
- name: NBFMreceive_0
  id: NBFMreceive
  parameters:
    Max_deviation: max_deviation
    RxOffset: '0'
    SIPpw: SIPpw
    SIPuri: SIPuri
    SIPuser: SIPuser
    aud_to_rf: samp_ratio
    audio_samp_rate: audio_samp_rate
    ctcss: ctcss
    squelch: squelch
  states: {}
- name: NBFMtransmit_0
  id: NBFMtransmit
  parameters:
    Max_deviation: max_deviation
    SIPpw: SIPpw
    SIPuri: SIPuri
    SIPuser: SIPuser
    TxOffset: '0'
    aud_to_rf: samp_ratio
    audio_samp_rate: audio_samp_rate
    ctcss: ctcss
    maxoutbuf: '1024'
  states: {}
- name: PSCR_LMR2LTE_sip_signaling_0
  id: PSCR_LMR2LTE_sip_signaling
  parameters:
    PCSCF_addr: sip:10.8.140.190:5050
    SIP_domain: mcptt01.pscr.lz
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: led_array_0
  id: led_array
  parameters:
    gui_hint: qtgui_tab_widget_0@0:0,0,1,1
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: audio_samp_rate*samp_ratio
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    gui_hint: qtgui_tab_widget_0@1:1,0,1,2
    label: '""'
    label1: '""'
    legend: 'False'
    name: '"Rx Spectrum"'
    tr_level: squelch
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: audio_samp_rate*samp_ratio
    fc: '0'
    fftsize: 2**14-1
    grid: 'True'
    gui_hint: qtgui_tab_widget_0@1:2,0,1,2
    label: '""'
    label1: '""'
    legend: 'False'
    name: '"Tx Spectrum"'
    tr_level: '0'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_tab_widget_0
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,1
    label0: Status
    label1: Advanced
    num_tabs: '2'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: qtgui_tab_widget_0@1:3,0,1,2
    name: '"Demodulated output"'
    size: '1024'
    srate: audio_samp_rate*samp_ratio
    tr_tag: '"squelch_sob"'
    type: float
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: uhd.tune_request(UL_freq, 200e3, args=uhd.device_addr("mode_n=integer"))
    comment: |-
      "type=b200"
      or
      "addr=10.8.105.215"
    dev_addr: SDR_address
    dev_args: '""'
    gain0: '40'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: audio_samp_rate*samp_ratio
    sd_spec0: '""'
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: uhd.tune_request(DL_freq, 200e3, args=uhd.device_addr("mode_n=integer"))
    comment: |-
      "type=b200" with RX2 antenna
      or
      "addr=10.8.105.215" with TX/RX antenna
      The LO offset is necessary 200kHz works well.

      Better performance is obtained if Clock Rate is set to 
      audio_samp_rate*samp_ratio, but some versions of GNU radio
      don't allow that.
    dc_offs_enb0: '""'
    dev_addr: SDR_address
    gain0: gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    rx_agc0: Disabled
    samp_rate: audio_samp_rate*samp_ratio
    sd_spec0: '""'
    sync: none
    type: fc32
  states: {}

connections:
- [NBFMreceive_0, '0', qtgui_time_sink_x_0, '0']
- [NBFMreceive_0, msg out, PSCR_LMR2LTE_sip_signaling_0, msg in]
- [NBFMreceive_0, msg out, blocks_message_debug_0, print]
- [NBFMtransmit_0, '0', qtgui_freq_sink_x_0_0, '0']
- [NBFMtransmit_0, '0', uhd_usrp_sink_0, '0']
- [NBFMtransmit_0, msg out, PSCR_LMR2LTE_sip_signaling_0, msg in]
- [NBFMtransmit_0, msg out, blocks_message_debug_0, print]
- [PSCR_LMR2LTE_sip_signaling_0, cmd out, NBFMreceive_0, msg in]
- [PSCR_LMR2LTE_sip_signaling_0, cmd out, NBFMtransmit_0, msg in]
- [PSCR_LMR2LTE_sip_signaling_0, cmd out, blocks_message_debug_0, print]
- [PSCR_LMR2LTE_sip_signaling_0, cmd out, led_array_0, msg in]
- [uhd_usrp_source_0, '0', NBFMreceive_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
