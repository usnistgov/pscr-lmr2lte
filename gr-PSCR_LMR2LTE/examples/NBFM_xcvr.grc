options:
  parameters:
    generate_options: qt_gui
    id: NBFM_xcvr
    output_language: python
    realtime_scheduling: '1'
    title: Narrowband 8 channel FM Transceiver
  states: {}

blocks:
- name: DL_freq
  id: variable
  parameters:
    value: 162.075e6
  states: {}
- name: NumChans
  id: variable
  parameters:
    value: '2'
  states: {}
- name: SDR_address
  id: variable
  parameters:
    value: '"type=b200"'
  states: {}
- name: UL_freq
  id: variable
  parameters:
    value: 158.7525e6
  states: {}
- name: audio_samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: gain
  id: variable
  parameters:
    comment: |-
      Don't set 
      less than 6
    value: '10'
  states: {}
- name: max_deviation
  id: variable
  parameters:
    value: '2500'
  states: {}
- name: samp_ratio
  id: variable
  parameters:
    value: '21'
  states: {}
- name: squelch
  id: variable_qtgui_range
  parameters:
    gui_hint: qtgui_tab_widget_0@1:0,0,1,2
    label: Power Squelch
    min_len: '100'
    orient: Qt.Horizontal
    start: '-100'
    step: '1'
    stop: '-20'
    value: '-40'
  states: {}
- name: PSCR_LMR2LTE_sip_signaling_0
  id: PSCR_LMR2LTE_sip_signaling
  parameters:
    PCSCF_addr: sip:10.8.140.190:5050
    SIP_domain: mcptt01.pscr.lz
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    comment: |-
      Scaling to keep the input 
      to the USRP sink between +/-1.
      Set to 0.5 for two NBFM 
      transmitters, 0.33 for three, etc.
    const: 1.0/NumChans
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {state: disabled}
- name: led_array_0
  id: led_array
  parameters:
    gui_hint: qtgui_tab_widget_0@0:0,0,1,1
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: audio_samp_rate*samp_ratio
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    gui_hint: qtgui_tab_widget_0@1:1,0,1,2
    label: '""'
    label1: '""'
    legend: 'False'
    name: '"Rx Spectrum"'
    tr_level: squelch
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: audio_samp_rate*samp_ratio
    fc: '0'
    fftsize: 2**14-1
    grid: 'True'
    gui_hint: qtgui_tab_widget_0@1:2,0,1,2
    label: '""'
    label1: '""'
    legend: 'False'
    name: '"Tx Spectrum"'
    tr_level: '0'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    type: float
  states: {state: disabled}
- name: qtgui_tab_widget_0
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,1
    label0: Status
    label1: Advanced
    num_tabs: '2'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: qtgui_tab_widget_0@1:3,0,1,2
    name: '"Demodulated output"'
    size: '1024'
    srate: audio_samp_rate*samp_ratio
    tr_tag: '"squelch_sob"'
    type: float
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: uhd.tune_request(UL_freq, 200e3, args=uhd.device_addr("mode_n=integer"))
    comment: |-
      "type=b200"
      or
      "addr=10.8.105.215"
    dev_addr: SDR_address
    dev_args: '"recv_buff_size=816000"'
    gain0: '-30'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: audio_samp_rate*samp_ratio
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: uhd.tune_request(DL_freq, 200e3, args=uhd.device_addr("mode_n=integer"))
    comment: |-
      "type=b200" with RX2 antenna
      or
      "addr=10.8.105.215" with TX/RX antenna
      The LO offset is necessary 200kHz works well.

      Better performance is obtained if Clock Rate is set to 
      audio_samp_rate*samp_ratio, but some versions of GNU radio
      don't allow that.
    dc_offs_enb0: '""'
    dev_addr: SDR_address
    dev_args: '"recv_buff_size=816000"'
    gain0: gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    rx_agc0: Disabled
    samp_rate: audio_samp_rate*samp_ratio
    sync: none
    type: fc32
  states: {}
- name: xcvr_array_0
  id: xcvr_array
  parameters:
    Max_deviation: '2500'
    RxOffset_1: '0'
    RxOffset_2: '0'
    RxOffset_3: '0'
    RxOffset_4: '0'
    RxOffset_5: '0'
    RxOffset_6: '0'
    RxOffset_7: '0'
    RxOffset_8: '0'
    SIPpw1: '"proxy-client-A"'
    SIPpw2: '""'
    SIPpw3: '""'
    SIPpw4: '""'
    SIPpw5: '""'
    SIPpw6: '""'
    SIPpw7: '""'
    SIPpw8: '""'
    SIPuri1: '"sip:mcptt_id_clientB@mcptt01.pscr.lz"'
    SIPuri2: '""'
    SIPuri3: '""'
    SIPuri4: '""'
    SIPuri5: '""'
    SIPuri6: '""'
    SIPuri7: '""'
    SIPuri8: '""'
    SIPuser1: '"proxy-client-A"'
    SIPuser2: '""'
    SIPuser3: '""'
    SIPuser4: '""'
    SIPuser5: '""'
    SIPuser6: '""'
    SIPuser7: '""'
    SIPuser8: '""'
    TxOffset_1: '0'
    TxOffset_2: '0'
    TxOffset_3: '0'
    TxOffset_4: '0'
    TxOffset_5: '0'
    TxOffset_6: '0'
    TxOffset_7: '0'
    TxOffset_8: '0'
    aud_to_rf: samp_ratio
    audio_samp_rate: audio_samp_rate
    ctcss_1: '179.9'
    ctcss_2: '67'
    ctcss_3: '0'
    ctcss_4: '0'
    ctcss_5: '0'
    ctcss_6: '0'
    ctcss_7: '0'
    ctcss_8: '0'
    squelch: squelch
  states: {}

connections:
- [PSCR_LMR2LTE_sip_signaling_0, cmd out, blocks_message_debug_0, print]
- [PSCR_LMR2LTE_sip_signaling_0, cmd out, led_array_0, msg in]
- [PSCR_LMR2LTE_sip_signaling_0, cmd out, xcvr_array_0, CMD_in]
- [blocks_multiply_const_xx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_multiply_const_xx_0, '0', uhd_usrp_sink_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', xcvr_array_0, '0']
- [xcvr_array_0, '0', blocks_multiply_const_xx_0, '0']
- [xcvr_array_0, '1', qtgui_number_sink_0, '0']
- [xcvr_array_0, '1', qtgui_time_sink_x_0, '0']
- [xcvr_array_0, MSG_out, PSCR_LMR2LTE_sip_signaling_0, msg in]
- [xcvr_array_0, MSG_out, blocks_message_debug_0, print]

metadata:
  file_format: 1
