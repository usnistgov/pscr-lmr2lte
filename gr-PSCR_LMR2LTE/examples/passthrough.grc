options:
  parameters:
    generate_options: qt_gui
    id: passthrough
    output_language: python
  states: {}

blocks:
- name: Audio_samp_rate
  id: variable
  parameters:
    value: '16000'
  states: {}
- name: SDR_address
  id: variable
  parameters:
    value: '"type=b200"'
  states: {}
- name: aud_to_rf
  id: variable
  parameters:
    value: '125'
  states: {}
- name: ctcss
  id: variable_qtgui_range
  parameters:
    label: CTCSS frequency
    orient: Qt.Horizontal
    start: '67'
    step: '.1'
    stop: '255'
    value: '179.9'
    widget: slider
  states: {}
- name: ctcss_e
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    label: CTCSS
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: downlink_freq
  id: variable
  parameters:
    value: 158.7525e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: Tx gain
    min_len: '100'
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '55'
    value: '30'
  states: {}
- name: mute
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    label: Mute
    'true': '1'
    type: real
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: squelch
  id: variable_qtgui_range
  parameters:
    label: Power Squelch
    min_len: '100'
    orient: Qt.Horizontal
    start: '-100'
    step: '1'
    stop: '-20'
    value: '-50'
  states: {}
- name: uplink_freq
  id: variable
  parameters:
    value: 162.075e6
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: Audio_samp_rate
    max_dev: '2500'
    quad_rate: Audio_samp_rate*aud_to_rf
    tau: '75e-12'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: Audio_samp_rate*aud_to_rf
    fh: '-1.0'
    max_dev: 2.5e3
    quad_rate: Audio_samp_rate*aud_to_rf
    tau: '75e-6'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '.5'
    comment: Dont drown the CTCSS!
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_pwr_squelch_xx_1
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '0.0001'
    comment: |-
      Power Squelch is set for 
      a fairly slow turn on/off time
    gate: 'False'
    ramp: int(0.05*Audio_samp_rate*aud_to_rf)
    threshold: squelch
    type: complex
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: 0.15*ctcss_e
    comment: |-
      CTCSS encoder levels are usually set for 15% of system deviation. 
      For example, in a 5 kHz deviation system, the CTCSS tone level 
      would normally be set to 750 Hz deviation.
    freq: ctcss
    offset: '0'
    phase: '0'
    samp_rate: Audio_samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '.5'
    comment: |-
      CTCSS encoder levels are usually set for 15% of system deviation. 
      For example, in a 5 kHz deviation system, the CTCSS tone level 
      would normally be set to 750 Hz deviation.
    freq: 1e3
    offset: '0'
    phase: '0'
    samp_rate: Audio_samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: Audio_samp_rate
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: mute
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/jodell/BabyElephantWalk60.wav
    repeat: 'True'
  states: {state: disabled}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: '275'
    decim: '1'
    gain: '1'
    samp_rate: Audio_samp_rate
    type: fir_filter_fff
    width: '25'
    win: firdes.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: Uplink channel
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Downlink channel
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    gui_hint: (0,2,3,1)
    label1: '"Rx"'
    name: '"B210 Downlink Spectrum"'
    tr_level: squelch
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    gui_hint: 0,3,3,1
    label1: '"Rx"'
    name: '"B210 Uplink Spectrum"'
    tr_level: squelch
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: Audio_samp_rate
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    label1: '"Rx"'
    name: '"NBFM Spectrum"'
    tr_level: squelch
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    fbw: '0.4'
    interp: aud_to_rf
    taps: ''
    type: fff
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: uhd.tune_request(uplink_freq, 200e3, args=uhd.device_addr("mode_n=integer"))
    comment: |-
      "type=b200"
      or
      "addr=10.8.105.215"
    dev_addr: '"type=b200"'
    dev_args: '""'
    gain0: '50'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: uhd.tune_request(downlink_freq, 200e3, args=uhd.device_addr("mode_n=integer"))
    dc_offs_enb0: '""'
    dev_addr: '"SDR_address"'
    dev_args: '""'
    gain0: '30'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_nbfm_rx_0, '0', qtgui_freq_sink_x_0_1, '0']
- [analog_nbfm_tx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_noise_source_x_0, '0', high_pass_filter_0, '0']
- [analog_pwr_squelch_xx_1, '0', analog_nbfm_rx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0_0_0, '0', high_pass_filter_0, '0']
- [audio_source_0, '0', high_pass_filter_0, '0']
- [blocks_add_xx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', uhd_usrp_sink_0, '0']
- [blocks_wavfile_source_0, '0', high_pass_filter_0, '0']
- [high_pass_filter_0, '0', blocks_add_xx_0, '0']
- [rational_resampler_xxx_0, '0', analog_nbfm_tx_0, '0']
- [uhd_usrp_source_1, '0', analog_pwr_squelch_xx_1, '0']
- [uhd_usrp_source_1, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
