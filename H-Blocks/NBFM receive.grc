options:
  parameters:
    generate_options: hb
    id: NBFMreceive
    output_language: python
    title: Analog NBFM receiver
  states: {}

blocks:
- name: MaxOutBuf
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: CTCSSdetect_0
  id: CTCSSdetect
  parameters:
    audio_samp_rate: audio_samp_rate
    ctcss: ctcss
  states: {}
- name: Max_deviation
  id: parameter
  parameters:
    hide: part
    label: Maximum Deviation (Hz)
    type: eng_float
    value: '2500'
  states: {}
- name: PSCR_LMR2LTE_opus_rtp_sink_0
  id: PSCR_LMR2LTE_opus_rtp_sink
  parameters:
    SIP_pw: SIPpw
    SIP_user: SIPuser
    addr: 127.0.0.1
    lport: '16384'
    rport: '16384'
    rx_freq_offset: RxOffset
    samprate: audio_samp_rate
    uri: SIPuri
  states: {}
- name: RxOffset
  id: parameter
  parameters:
    hide: part
    label: Rx Frequency Offset (Hz)
    type: eng_float
    value: '0'
  states: {}
- name: SIPpw
  id: parameter
  parameters:
    hide: part
    label: SIP password
    type: str
    value: '""'
  states: {}
- name: SIPuri
  id: parameter
  parameters:
    hide: part
    label: SIP URI to call
    type: str
    value: '""'
  states: {}
- name: SIPuser
  id: parameter
  parameters:
    hide: part
    label: SIP user name
    type: str
    value: '""'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: audio_samp_rate
    max_dev: '2500'
    maxoutbuf: MaxOutBuf
    quad_rate: audio_samp_rate
    tau: '75e-6'
  states: {}
- name: analog_pwr_squelch_xx_1
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '0.01'
    comment: |-
      Power Squelch is set for 
      a fairly slow turn on/off time
    gate: 'False'
    maxoutbuf: MaxOutBuf
    ramp: int(0.05*audio_samp_rate)
    threshold: squelch
    type: complex
  states: {}
- name: aud_to_rf
  id: parameter
  parameters:
    hide: part
    label: Sample Rate to Audio Rate ratio
    type: intx
    value: '21'
  states: {}
- name: audio_samp_rate
  id: parameter
  parameters:
    hide: part
    label: Audio Sample Rate
    type: intx
    value: '48000'
  states: {}
- name: blocks_copy_0
  id: blocks_copy
  parameters:
    comment: |-
      Copy will be enabled 
      if SIPuser is specified
    enabled: bool(len(SIPuser))
    maxoutbuf: MaxOutBuf
    type: complex
  states: {}
- name: blocks_multiply_matrix_xx_0
  id: blocks_multiply_matrix_xx
  parameters:
    A: '[[not(ctcss>60), (ctcss>60)]]'
    comment: |-
      Forward data and tags
      as controlled by ctcss enable
    maxoutbuf: '10240'
    tag_propagation_policy: gr.TPP_CUSTOM
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    comment: |-
      Zero out data 
      when the squelch
      threshold is not
      reached. 
      (faster than
      Power Squelch 
      to block noise 
      at end of 
      transmission)
    maxoutbuf: '10240'
    type: float
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    maxoutbuf: MaxOutBuf
    n: '20'
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '1'
    comment: |-
      Set for a faster reaction 
      than power squelch to
      enable fast turn off
    maxoutbuf: MaxOutBuf
    type: complex
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_tag_debug_1
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: squelch
    init: '0'
    low: squelch-1
    maxoutbuf: MaxOutBuf
  states: {}
- name: ctcss
  id: parameter
  parameters:
    hide: part
    label: CTCSS Frequency (Hz)
    type: eng_float
    value: '0'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: RxOffset
    decim: aud_to_rf
    maxoutbuf: MaxOutBuf
    samp_rate: audio_samp_rate*aud_to_rf
    taps: firdes.complex_band_pass(1, audio_samp_rate*aud_to_rf, -audio_samp_rate/2, audio_samp_rate/2, 1000)
    type: ccc
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: '250'
    gain: '1'
    interp: '1'
    maxoutbuf: MaxOutBuf
    samp_rate: audio_samp_rate
    type: interp_fir_filter_fff
    width: '25'
    win: firdes.WIN_HAMMING
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: msg out
    optional: 'True'
    type: message
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: demod out
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: msg in
    optional: 'True'
    type: message
  states: {}
- name: squelch
  id: parameter
  parameters:
    hide: part
    label: Squelch Level (dB)
    type: eng_float
    value: '-80'
  states: {}

connections:
- [CTCSSdetect_0, '0', blocks_multiply_matrix_xx_0, '1']
- [PSCR_LMR2LTE_opus_rtp_sink_0, squelch, pad_sink_0, in]
- [analog_nbfm_rx_0, '0', blocks_multiply_xx_0, '0']
- [analog_nbfm_rx_0, '0', pad_sink_1, '0']
- [analog_pwr_squelch_xx_1, '0', analog_nbfm_rx_0, '0']
- [analog_pwr_squelch_xx_1, '0', blocks_tag_debug_1, '0']
- [blocks_copy_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_multiply_matrix_xx_0, '0', high_pass_filter_0, '0']
- [blocks_multiply_xx_0, '0', CTCSSdetect_0, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_matrix_xx_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_threshold_ff_0, '0']
- [blocks_rms_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_threshold_ff_0, '0', blocks_multiply_xx_0, '1']
- [freq_xlating_fir_filter_xxx_0, '0', analog_pwr_squelch_xx_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_rms_xx_0, '0']
- [high_pass_filter_0, '0', PSCR_LMR2LTE_opus_rtp_sink_0, '0']
- [high_pass_filter_0, '0', blocks_tag_debug_0, '0']
- [pad_source_0, '0', blocks_copy_0, '0']
- [pad_source_1, out, PSCR_LMR2LTE_opus_rtp_sink_0, command]

metadata:
  file_format: 1
