options:
  parameters:
    generate_options: hb_qt_gui
    id: led_array
    output_language: python
    title: LED Array
  states: {}

blocks:
- name: CH1
  id: PSCR_LMR2LTE_label
  parameters:
    cellalignment: '2'
    gui_hint: (0,3,1,1)
    label: '""'
    verticalalignment: '1'
  states: {}
- name: CH1_Call
  id: PSCR_LMR2LTE_led
  parameters:
    cellalignment: '1'
    color: transparent
    gui_hint: 0,1,1,1
    label: '"Call"'
    maxSize: '40'
    position: '1'
    verticalalignment: '1'
  states: {}
- name: CH1_Floor
  id: PSCR_LMR2LTE_led
  parameters:
    cellalignment: '1'
    color: transparent
    gui_hint: 0,2,1,1
    label: '"Floor"'
    maxSize: '40'
    position: '1'
    verticalalignment: '1'
  states: {}
- name: CH1_Reg
  id: PSCR_LMR2LTE_led
  parameters:
    alias: LED1
    cellalignment: '2'
    color: transparent
    gui_hint: (0,0,1,1)
    label: '"Register"'
    maxSize: '40'
    position: '1'
    verticalalignment: '1'
  states: {}
- name: CH2
  id: PSCR_LMR2LTE_label
  parameters:
    cellalignment: '2'
    gui_hint: (1,3,1,1)
    label: '""'
    verticalalignment: '1'
  states: {}
- name: CH2_Call
  id: PSCR_LMR2LTE_led
  parameters:
    cellalignment: '1'
    color: transparent
    gui_hint: 1,1,1,1
    label: ''
    maxSize: '40'
    position: '1'
    verticalalignment: '1'
  states: {}
- name: CH2_Floor
  id: PSCR_LMR2LTE_led
  parameters:
    cellalignment: '1'
    color: transparent
    gui_hint: 1,2,1,1
    label: ''
    maxSize: '40'
    position: '1'
    verticalalignment: '1'
  states: {}
- name: CH2_Reg
  id: PSCR_LMR2LTE_led
  parameters:
    cellalignment: '2'
    color: transparent
    gui_hint: 1,0,1,1
    label: ''
    maxSize: '40'
    position: '1'
    verticalalignment: '1'
  states: {}
- name: CH3
  id: PSCR_LMR2LTE_label
  parameters:
    cellalignment: '2'
    gui_hint: (2,3,1,1)
    label: '""'
    verticalalignment: '1'
  states: {}
- name: CH3_Call
  id: PSCR_LMR2LTE_led
  parameters:
    cellalignment: '1'
    color: transparent
    gui_hint: 2,1,1,1
    label: ''
    maxSize: '40'
    position: '1'
    verticalalignment: '1'
  states: {}
- name: CH3_Floor
  id: PSCR_LMR2LTE_led
  parameters:
    cellalignment: '1'
    color: transparent
    gui_hint: 2,2,1,1
    label: ''
    maxSize: '40'
    position: '1'
    verticalalignment: '1'
  states: {}
- name: CH3_Reg
  id: PSCR_LMR2LTE_led
  parameters:
    cellalignment: '2'
    color: transparent
    gui_hint: 2,0,1,1
    label: ''
    maxSize: '40'
    position: '1'
    verticalalignment: '1'
  states: {}
- name: CH4
  id: PSCR_LMR2LTE_label
  parameters:
    cellalignment: '2'
    gui_hint: (3,3,1,1)
    label: '""'
    verticalalignment: '1'
  states: {}
- name: CH4_Call
  id: PSCR_LMR2LTE_led
  parameters:
    cellalignment: '1'
    color: transparent
    gui_hint: 3,1,1,1
    label: ''
    maxSize: '40'
    position: '1'
    verticalalignment: '1'
  states: {}
- name: CH4_Floor
  id: PSCR_LMR2LTE_led
  parameters:
    cellalignment: '1'
    color: transparent
    gui_hint: 3,2,1,1
    label: ''
    maxSize: '40'
    position: '1'
    verticalalignment: '1'
  states: {}
- name: CH4_Reg
  id: PSCR_LMR2LTE_led
  parameters:
    cellalignment: '2'
    color: transparent
    gui_hint: 3,0,1,1
    label: ''
    maxSize: '40'
    position: '1'
    verticalalignment: '1'
  states: {}
- name: CH5
  id: PSCR_LMR2LTE_label
  parameters:
    cellalignment: '2'
    gui_hint: (4,3,1,1)
    label: '""'
    verticalalignment: '1'
  states: {}
- name: CH5_Call
  id: PSCR_LMR2LTE_led
  parameters:
    cellalignment: '1'
    color: transparent
    gui_hint: 4,1,1,1
    label: ''
    maxSize: '40'
    position: '1'
    verticalalignment: '1'
  states: {}
- name: CH5_Floor
  id: PSCR_LMR2LTE_led
  parameters:
    cellalignment: '1'
    color: transparent
    gui_hint: 4,2,1,1
    label: ''
    maxSize: '40'
    position: '1'
    verticalalignment: '1'
  states: {}
- name: CH5_Reg
  id: PSCR_LMR2LTE_led
  parameters:
    cellalignment: '2'
    color: transparent
    gui_hint: 4,0,1,1
    label: ''
    maxSize: '40'
    position: '1'
    verticalalignment: '1'
  states: {}
- name: CH6
  id: PSCR_LMR2LTE_label
  parameters:
    cellalignment: '2'
    gui_hint: (5,3,1,1)
    label: '""'
    verticalalignment: '1'
  states: {}
- name: CH6_Call
  id: PSCR_LMR2LTE_led
  parameters:
    cellalignment: '1'
    color: transparent
    gui_hint: 5,1,1,1
    label: ''
    maxSize: '40'
    position: '1'
    verticalalignment: '1'
  states: {}
- name: CH6_Floor
  id: PSCR_LMR2LTE_led
  parameters:
    cellalignment: '1'
    color: transparent
    gui_hint: 5,2,1,1
    label: ''
    maxSize: '40'
    position: '1'
    verticalalignment: '1'
  states: {}
- name: CH6_Reg
  id: PSCR_LMR2LTE_led
  parameters:
    cellalignment: '2'
    color: transparent
    gui_hint: 5,0,1,1
    label: ''
    maxSize: '40'
    position: '1'
    verticalalignment: '1'
  states: {}
- name: CH7
  id: PSCR_LMR2LTE_label
  parameters:
    cellalignment: '2'
    gui_hint: (6,3,1,1)
    label: '""'
    verticalalignment: '1'
  states: {}
- name: CH7_Call
  id: PSCR_LMR2LTE_led
  parameters:
    cellalignment: '1'
    color: transparent
    gui_hint: 6,1,1,1
    label: ''
    maxSize: '40'
    position: '1'
    verticalalignment: '1'
  states: {}
- name: CH7_Floor
  id: PSCR_LMR2LTE_led
  parameters:
    cellalignment: '1'
    color: transparent
    gui_hint: 6,2,1,1
    label: ''
    maxSize: '40'
    position: '1'
    verticalalignment: '1'
  states: {}
- name: CH7_Reg
  id: PSCR_LMR2LTE_led
  parameters:
    cellalignment: '2'
    color: transparent
    gui_hint: 6,0,1,1
    label: ''
    maxSize: '40'
    position: '1'
    verticalalignment: '1'
  states: {}
- name: CH8
  id: PSCR_LMR2LTE_label
  parameters:
    cellalignment: '2'
    gui_hint: (7,3,1,1)
    label: '""'
    verticalalignment: '1'
  states: {}
- name: CH8_Call
  id: PSCR_LMR2LTE_led
  parameters:
    cellalignment: '1'
    color: transparent
    gui_hint: 7,1,1,1
    label: ''
    maxSize: '40'
    position: '1'
    verticalalignment: '1'
  states: {}
- name: CH8_Floor
  id: PSCR_LMR2LTE_led
  parameters:
    cellalignment: '1'
    color: transparent
    gui_hint: 7,2,1,1
    label: ''
    maxSize: '40'
    position: '1'
    verticalalignment: '1'
  states: {}
- name: CH8_Reg
  id: PSCR_LMR2LTE_led
  parameters:
    cellalignment: '2'
    color: transparent
    gui_hint: 7,0,1,1
    label: ''
    maxSize: '40'
    position: '1'
    verticalalignment: '1'
  states: {}
- name: import_0
  id: import
  parameters:
    comment: |-
      Due to a bug in gnuradio this import block is needed
      https://github.com/gnuradio/gnuradio/issues/4431
    imports: from PyQt5 import Qt
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: msg in
    type: message
  states: {}

connections:
- [pad_source_0, out, CH1, label]
- [pad_source_0, out, CH1_Call, color]
- [pad_source_0, out, CH1_Floor, color]
- [pad_source_0, out, CH1_Reg, color]
- [pad_source_0, out, CH2, label]
- [pad_source_0, out, CH2_Call, color]
- [pad_source_0, out, CH2_Floor, color]
- [pad_source_0, out, CH2_Reg, color]
- [pad_source_0, out, CH3, label]
- [pad_source_0, out, CH3_Call, color]
- [pad_source_0, out, CH3_Floor, color]
- [pad_source_0, out, CH3_Reg, color]
- [pad_source_0, out, CH4, label]
- [pad_source_0, out, CH4_Call, color]
- [pad_source_0, out, CH4_Floor, color]
- [pad_source_0, out, CH4_Reg, color]
- [pad_source_0, out, CH5, label]
- [pad_source_0, out, CH5_Call, color]
- [pad_source_0, out, CH5_Floor, color]
- [pad_source_0, out, CH5_Reg, color]
- [pad_source_0, out, CH6, label]
- [pad_source_0, out, CH6_Call, color]
- [pad_source_0, out, CH6_Floor, color]
- [pad_source_0, out, CH6_Reg, color]
- [pad_source_0, out, CH7, label]
- [pad_source_0, out, CH7_Call, color]
- [pad_source_0, out, CH7_Floor, color]
- [pad_source_0, out, CH7_Reg, color]
- [pad_source_0, out, CH8, label]
- [pad_source_0, out, CH8_Call, color]
- [pad_source_0, out, CH8_Floor, color]
- [pad_source_0, out, CH8_Reg, color]

metadata:
  file_format: 1
