options:
  parameters:
    generate_options: hb
    id: NBFMtransmit
    output_language: python
    title: Analog NBFM transmitter
  states: {}

blocks:
- name: MaxOutBuf
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: Max_deviation
  id: parameter
  parameters:
    hide: part
    label: Maximum Deviation (Hz)
    type: eng_float
    value: '2500'
  states: {}
- name: PSCR_LMR2LTE_opus_rtp_source_0
  id: PSCR_LMR2LTE_opus_rtp_source
  parameters:
    SIP_pw: SIPpw
    SIP_user: SIPuser
    ipv6: 'False'
    port: '0'
    samprate: audio_samp_rate
    tx_freq_offset: TxOffset
    uri: SIPuri
  states: {}
- name: SIPpw
  id: parameter
  parameters:
    hide: part
    label: SIP password
    type: str
    value: '""'
  states: {}
- name: SIPuri
  id: parameter
  parameters:
    hide: part
    label: SIP URI to call
    type: str
    value: '""'
  states: {}
- name: SIPuser
  id: parameter
  parameters:
    hide: part
    label: SIP user name
    type: str
    value: '""'
  states: {}
- name: TxOffset
  id: parameter
  parameters:
    hide: part
    label: Tx Frequency Offset (Hz)
    type: eng_float
    value: '0'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: audio_samp_rate*aud_to_rf
    fh: '-1.0'
    max_dev: 2.5e3
    maxoutbuf: MaxOutBuf
    quad_rate: audio_samp_rate*aud_to_rf
    tau: '75e-6'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: |-
      Frequency Xlator to
      allow for multiple
      channels per SDR
    freq: TxOffset
    maxoutbuf: '2048'
    offset: '0'
    phase: '0'
    samp_rate: aud_to_rf*audio_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: 0.15*(ctcss>60)
    comment: |-
      CTCSS encoder levels are usually 
      set for 15% of system deviation. 
      For example, in a 5 kHz deviation 
      system, the CTCSS tone level 
      would normally be set to 
      750 Hz deviation.
    freq: ctcss
    maxoutbuf: '2048'
    offset: '0'
    phase: '0'
    samp_rate: audio_samp_rate*aud_to_rf
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: aud_to_rf
  id: parameter
  parameters:
    hide: part
    label: Sample Rate to Audio Rate ratio
    type: intx
    value: '21'
  states: {}
- name: audio_samp_rate
  id: parameter
  parameters:
    hide: part
    label: Audio Sample Rate
    type: intx
    value: '48000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    maxoutbuf: MaxOutBuf
    type: float
  states: {}
- name: blocks_multiply_by_tag_value_cc_0
  id: blocks_multiply_by_tag_value_cc
  parameters:
    maxoutbuf: MaxOutBuf
    tagname: udp_data
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    maxoutbuf: MaxOutBuf
    type: complex
  states: {}
- name: ctcss
  id: parameter
  parameters:
    hide: part
    label: CTCSS Frequency (Hz)
    type: eng_float
    value: '0'
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    comment: |-
      Filter to prevent audio 
      from interfering with CTCSS
      Interpolation does not work
    cutoff_freq: (ctcss>0)*275+25
    gain: '1'
    interp: '1'
    samp_rate: audio_samp_rate
    type: interp_fir_filter_fff
    width: '25'
    win: firdes.WIN_HAMMING
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: msg out
    optional: 'True'
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: msg in
    optional: 'True'
    type: message
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    fbw: '0.4'
    interp: aud_to_rf
    maxoutbuf: MaxOutBuf
    taps: ''
    type: fff
  states: {}

connections:
- [PSCR_LMR2LTE_opus_rtp_source_0, '0', high_pass_filter_0, '0']
- [PSCR_LMR2LTE_opus_rtp_source_0, cmd out, pad_sink_1, in]
- [analog_nbfm_tx_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', analog_nbfm_tx_0, '0']
- [blocks_multiply_by_tag_value_cc_0, '0', pad_sink_0, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_by_tag_value_cc_0, '0']
- [high_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [pad_source_0, out, PSCR_LMR2LTE_opus_rtp_source_0, command]
- [rational_resampler_xxx_0, '0', blocks_add_xx_0, '1']

metadata:
  file_format: 1
