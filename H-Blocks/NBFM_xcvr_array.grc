options:
  parameters:
    generate_options: hb
    id: xcvr_array
    output_language: python
    title: NBFM Transceiver Array
  states: {}

blocks:
- name: SIPuser1
  id: parameter
  parameters:
    hide: part
    label: Chan 1 SIP user name
    type: str
    value: '""'
  states: {}
- name: SIPpw1
  id: parameter
  parameters:
    hide: part
    label: Chan 1 SIP password
    type: str
    value: '""'
  states: {}
- name: SIPuri1
  id: parameter
  parameters:
    hide: part
    label: Chan 1 SIP URI to call
    type: str
    value: '""'
  states: {}
- name: RxOffset_1
  id: parameter
  parameters:
    hide: part
    label: Chan 1 Rx Offset (Hz)
    type: eng_float
    value: '0'
  states: {}
- name: TxOffset_1
  id: parameter
  parameters:
    hide: part
    label: Chan 1 Tx Offset (Hz)
    type: eng_float
    value: '0'
  states: {}
- name: ctcss_1
  id: parameter
  parameters:
    hide: part
    label: Chan 1 CTCSS Freq (Hz)
    type: eng_float
    value: '179.9'
  states: {}
- name: SIPuser2
  id: parameter
  parameters:
    hide: part
    label: Chan 2 SIP user name
    type: str
    value: '""'
  states: {}
- name: SIPpw2
  id: parameter
  parameters:
    hide: part
    label: Chan 2 SIP password
    type: str
    value: '""'
  states: {}
- name: SIPuri2
  id: parameter
  parameters:
    hide: part
    label: Chan 2 SIP URI to call
    type: str
    value: '""'
  states: {}
- name: RxOffset_2
  id: parameter
  parameters:
    hide: part
    label: Chan 2 Rx Offset (Hz)
    type: eng_float
    value: '0'
  states: {}
- name: TxOffset_2
  id: parameter
  parameters:
    hide: part
    label: Chan 2 Tx Offset (Hz)
    type: eng_float
    value: '0'
  states: {}
- name: ctcss_2
  id: parameter
  parameters:
    hide: part
    label: Chan 2 CTCSS Freq (Hz)
    type: eng_float
    value: '69.3'
  states: {}
- name: SIPuser3
  id: parameter
  parameters:
    hide: part
    label: Chan 3 SIP user name
    type: str
    value: '""'
  states: {}
- name: SIPpw3
  id: parameter
  parameters:
    hide: part
    label: Chan 3 SIP password
    type: str
    value: '""'
  states: {}
- name: SIPuri3
  id: parameter
  parameters:
    hide: part
    label: Chan 3 SIP URI to call
    type: str
    value: '""'
  states: {}
- name: RxOffset_3
  id: parameter
  parameters:
    hide: part
    label: Chan 3 Rx Offset (Hz)
    type: eng_float
    value: '0'
  states: {}
- name: TxOffset_3
  id: parameter
  parameters:
    hide: part
    label: Chan 3 Tx Offset (Hz)
    type: eng_float
    value: '0'
  states: {}
- name: ctcss_3
  id: parameter
  parameters:
    hide: part
    label: Chan 3 CTCSS Freq (Hz)
    type: eng_float
    value: '71.9'
  states: {}
- name: SIPuser4
  id: parameter
  parameters:
    hide: part
    label: Chan 4 SIP user name
    type: str
    value: '""'
  states: {}
- name: SIPpw4
  id: parameter
  parameters:
    hide: part
    label: Chan 4 SIP password
    type: str
    value: '""'
  states: {}
- name: SIPuri4
  id: parameter
  parameters:
    hide: part
    label: Chan 4 SIP URI to call
    type: str
    value: '""'
  states: {}
- name: RxOffset_4
  id: parameter
  parameters:
    hide: part
    label: Chan 4 Rx Offset (Hz)
    type: eng_float
    value: '0'
  states: {}
- name: TxOffset_4
  id: parameter
  parameters:
    hide: part
    label: Chan 4 Tx Offset (Hz)
    type: eng_float
    value: '0'
  states: {}
- name: ctcss_4
  id: parameter
  parameters:
    hide: part
    label: Chan 4 CTCSS Freq (Hz)
    type: eng_float
    value: '100'
  states: {}
- name: SIPuser5
  id: parameter
  parameters:
    hide: part
    label: Chan 5 SIP user name
    type: str
    value: '""'
  states: {}
- name: SIPpw5
  id: parameter
  parameters:
    hide: part
    label: Chan 5 SIP password
    type: str
    value: '""'
  states: {}
- name: SIPuri5
  id: parameter
  parameters:
    hide: part
    label: Chan 5 SIP URI to call
    type: str
    value: '""'
  states: {}
- name: RxOffset_5
  id: parameter
  parameters:
    hide: part
    label: Chan 5 Rx Offset (Hz)
    type: eng_float
    value: '0'
  states: {}
- name: TxOffset_5
  id: parameter
  parameters:
    hide: part
    label: Chan 5 Tx Offset (Hz)
    type: eng_float
    value: '0'
  states: {}
- name: ctcss_5
  id: parameter
  parameters:
    hide: part
    label: Chan 5 CTCSS Freq (Hz)
    type: eng_float
    value: '179.9'
  states: {}
- name: SIPuser6
  id: parameter
  parameters:
    hide: part
    label: Chan 6 SIP user name
    type: str
    value: '""'
  states: {}
- name: SIPpw6
  id: parameter
  parameters:
    hide: part
    label: Chan 6 SIP password
    type: str
    value: '""'
  states: {}
- name: SIPuri6
  id: parameter
  parameters:
    hide: part
    label: Chan 6 SIP URI to call
    type: str
    value: '""'
  states: {}
- name: RxOffset_6
  id: parameter
  parameters:
    hide: part
    label: Chan 6 Rx Offset (Hz)
    type: eng_float
    value: '0'
  states: {}
- name: TxOffset_6
  id: parameter
  parameters:
    hide: part
    label: Chan 6 Tx Offset (Hz)
    type: eng_float
    value: '0'
  states: {}
- name: ctcss_6
  id: parameter
  parameters:
    hide: part
    label: Chan 6 CTCSS Freq (Hz)
    type: eng_float
    value: '241.8'
  states: {}
- name: SIPuser7
  id: parameter
  parameters:
    hide: part
    label: Chan 7 SIP user name
    type: str
    value: '""'
  states: {}
- name: SIPpw7
  id: parameter
  parameters:
    hide: part
    label: Chan 7 SIP password
    type: str
    value: '""'
  states: {}
- name: SIPuri7
  id: parameter
  parameters:
    hide: part
    label: Chan 7 SIP URI to call
    type: str
    value: '""'
  states: {}
- name: RxOffset_7
  id: parameter
  parameters:
    hide: part
    label: Chan 7 Rx Offset (Hz)
    type: eng_float
    value: '0'
  states: {}
- name: TxOffset_7
  id: parameter
  parameters:
    hide: part
    label: Chan 7 Tx Offset (Hz)
    type: eng_float
    value: '0'
  states: {}
- name: ctcss_7
  id: parameter
  parameters:
    hide: part
    label: Chan 7 CTCSS Freq (Hz)
    type: eng_float
    value: '250.3'
  states: {}
- name: SIPuser8
  id: parameter
  parameters:
    hide: part
    label: Chan 8 SIP user name
    type: str
    value: '""'
  states: {}
- name: SIPpw8
  id: parameter
  parameters:
    hide: part
    label: Chan 8 SIP password
    type: str
    value: '""'
  states: {}
- name: SIPuri8
  id: parameter
  parameters:
    hide: part
    label: Chan 8 SIP URI to call
    type: str
    value: '""'
  states: {}
- name: RxOffset_8
  id: parameter
  parameters:
    hide: part
    label: Chan 8 Rx Offset (Hz)
    type: eng_float
    value: '0'
  states: {}
- name: TxOffset_8
  id: parameter
  parameters:
    hide: part
    label: Chan 8 Tx Offset (Hz)
    type: eng_float
    value: '0'
  states: {}
- name: ctcss_8
  id: parameter
  parameters:
    hide: part
    label: Chan 8 CTCSS Freq (Hz)
    type: eng_float
    value: '254.1'
  states: {}
- name: aud_to_rf
  id: parameter
  parameters:
    hide: part
    label: Sample Rate to Audio Rate ratio
    type: intx
    value: '21'
  states: {}
- name: audio_samp_rate
  id: parameter
  parameters:
    hide: part
    label: Audio Sample Rate
    type: intx
    value: '48000'
  states: {}
- name: squelch
  id: parameter
  parameters:
    hide: part
    label: Squelch Level (dB)
    type: eng_float
    value: '-40'
  states: {}
- name: Max_deviation
  id: parameter
  parameters:
    hide: part
    label: Maximum Deviation (Hz)
    type: eng_float
    value: '2500'
  states: {}
- name: NBFMreceive_1
  id: NBFMreceive
  parameters:
    Max_deviation: Max_deviation
    RxOffset: RxOffset_1
    SIPpw: SIPpw1
    SIPuri: SIPuri1
    SIPuser: SIPuser1
    alias: '"1"'
    aud_to_rf: aud_to_rf
    audio_samp_rate: audio_samp_rate
    ctcss: ctcss_1
    squelch: squelch
  states: {}
- name: NBFMreceive_2
  id: NBFMreceive
  parameters:
    Max_deviation: Max_deviation
    RxOffset: RxOffset_2
    SIPpw: SIPpw2
    SIPuri: SIPuri2
    SIPuser: SIPuser2
    aud_to_rf: aud_to_rf
    audio_samp_rate: audio_samp_rate
    ctcss: ctcss_2
    squelch: squelch
  states: {}
- name: NBFMreceive_3
  id: NBFMreceive
  parameters:
    Max_deviation: Max_deviation
    RxOffset: RxOffset_3
    SIPpw: SIPpw3
    SIPuri: SIPuri3
    SIPuser: SIPuser3
    aud_to_rf: aud_to_rf
    audio_samp_rate: audio_samp_rate
    ctcss: ctcss_3
    squelch: squelch
  states: {}
- name: NBFMreceive_4
  id: NBFMreceive
  parameters:
    Max_deviation: Max_deviation
    RxOffset: RxOffset_4
    SIPpw: SIPpw4
    SIPuri: SIPuri4
    SIPuser: SIPuser4
    aud_to_rf: aud_to_rf
    audio_samp_rate: audio_samp_rate
    ctcss: ctcss_4
    squelch: squelch
  states: {}
- name: NBFMreceive_5
  id: NBFMreceive
  parameters:
    Max_deviation: Max_deviation
    RxOffset: RxOffset_5
    SIPpw: SIPpw5
    SIPuri: SIPuri5
    SIPuser: SIPuser5
    aud_to_rf: aud_to_rf
    audio_samp_rate: audio_samp_rate
    ctcss: ctcss_5
    squelch: squelch
  states: {}
- name: NBFMreceive_6
  id: NBFMreceive
  parameters:
    Max_deviation: Max_deviation
    RxOffset: RxOffset_6
    SIPpw: SIPpw6
    SIPuri: SIPuri6
    SIPuser: SIPuser6
    aud_to_rf: aud_to_rf
    audio_samp_rate: audio_samp_rate
    ctcss: ctcss_6
    squelch: squelch
  states: {}
- name: NBFMreceive_7
  id: NBFMreceive
  parameters:
    Max_deviation: Max_deviation
    RxOffset: RxOffset_7
    SIPpw: SIPpw7
    SIPuri: SIPuri7
    SIPuser: SIPuser7
    aud_to_rf: aud_to_rf
    audio_samp_rate: audio_samp_rate
    ctcss: ctcss_7
    squelch: squelch
  states: {}
- name: NBFMreceive_8
  id: NBFMreceive
  parameters:
    Max_deviation: Max_deviation
    RxOffset: RxOffset_8
    SIPpw: SIPpw8
    SIPuri: SIPuri8
    SIPuser: SIPuser8
    aud_to_rf: aud_to_rf
    audio_samp_rate: audio_samp_rate
    ctcss: ctcss_8
    squelch: squelch
  states: {}
- name: NBFMtransmit_1
  id: NBFMtransmit
  parameters:
    Max_deviation: Max_deviation
    SIPpw: SIPpw1
    SIPuri: SIPuri1
    SIPuser: SIPuser1
    TxOffset: TxOffset_1
    aud_to_rf: aud_to_rf
    audio_samp_rate: audio_samp_rate
    ctcss: ctcss_1
  states: {}
- name: NBFMtransmit_2
  id: NBFMtransmit
  parameters:
    Max_deviation: Max_deviation
    SIPpw: SIPpw2
    SIPuri: SIPuri2
    SIPuser: SIPuser2
    TxOffset: TxOffset_2
    aud_to_rf: aud_to_rf
    audio_samp_rate: audio_samp_rate
    ctcss: ctcss_2
  states: {}
- name: NBFMtransmit_3
  id: NBFMtransmit
  parameters:
    Max_deviation: Max_deviation
    SIPpw: SIPpw3
    SIPuri: SIPuri3
    SIPuser: SIPuser3
    TxOffset: TxOffset_3
    aud_to_rf: aud_to_rf
    audio_samp_rate: audio_samp_rate
    ctcss: ctcss_3
  states: {}
- name: NBFMtransmit_4
  id: NBFMtransmit
  parameters:
    Max_deviation: Max_deviation
    SIPpw: SIPpw4
    SIPuri: SIPuri4
    SIPuser: SIPuser4
    TxOffset: TxOffset_4
    aud_to_rf: aud_to_rf
    audio_samp_rate: audio_samp_rate
    ctcss: ctcss_4
  states: {}
- name: NBFMtransmit_5
  id: NBFMtransmit
  parameters:
    Max_deviation: Max_deviation
    SIPpw: SIPpw5
    SIPuri: SIPuri5
    SIPuser: SIPuser5
    TxOffset: TxOffset_5
    aud_to_rf: aud_to_rf
    audio_samp_rate: audio_samp_rate
    ctcss: ctcss_5
  states: {}
- name: NBFMtransmit_6
  id: NBFMtransmit
  parameters:
    Max_deviation: Max_deviation
    SIPpw: SIPpw6
    SIPuri: SIPuri6
    SIPuser: SIPuser6
    TxOffset: TxOffset_6
    aud_to_rf: aud_to_rf
    audio_samp_rate: audio_samp_rate
    ctcss: ctcss_6
  states: {}
- name: NBFMtransmit_7
  id: NBFMtransmit
  parameters:
    Max_deviation: Max_deviation
    SIPpw: SIPpw7
    SIPuri: SIPuri7
    SIPuser: SIPuser7
    TxOffset: TxOffset_7
    aud_to_rf: aud_to_rf
    audio_samp_rate: audio_samp_rate
    ctcss: ctcss_7
  states: {}
- name: NBFMtransmit_8
  id: NBFMtransmit
  parameters:
    Max_deviation: Max_deviation
    SIPpw: SIPpw8
    SIPuri: SIPuri8
    SIPuser: SIPuser8
    TxOffset: TxOffset_8
    aud_to_rf: aud_to_rf
    audio_samp_rate: audio_samp_rate
    ctcss: ctcss_8
  states: {}
- name: add
  id: blocks_add_xx
  parameters:
    num_inputs: '8'
    type: complex
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: MSG_out
    type: message
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_sink_2
  id: pad_sink
  parameters:
    label: demod out
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: RF_in
    type: complex
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: CMD_in
    type: message
  states: {}

connections:
- [NBFMreceive_1, '0', pad_sink_2, '0']
- [NBFMreceive_1, msg out, pad_sink_0, in]
- [NBFMreceive_2, msg out, pad_sink_0, in]
- [NBFMreceive_3, msg out, pad_sink_0, in]
- [NBFMreceive_4, msg out, pad_sink_0, in]
- [NBFMreceive_5, msg out, pad_sink_0, in]
- [NBFMreceive_6, msg out, pad_sink_0, in]
- [NBFMreceive_7, msg out, pad_sink_0, in]
- [NBFMreceive_8, msg out, pad_sink_0, in]
- [NBFMtransmit_1, '0', add, '0']
- [NBFMtransmit_1, msg out, pad_sink_0, in]
- [NBFMtransmit_2, '0', add, '1']
- [NBFMtransmit_2, msg out, pad_sink_0, in]
- [NBFMtransmit_3, '0', add, '2']
- [NBFMtransmit_3, msg out, pad_sink_0, in]
- [NBFMtransmit_4, '0', add, '3']
- [NBFMtransmit_4, msg out, pad_sink_0, in]
- [NBFMtransmit_5, '0', add, '4']
- [NBFMtransmit_5, msg out, pad_sink_0, in]
- [NBFMtransmit_6, '0', add, '5']
- [NBFMtransmit_6, msg out, pad_sink_0, in]
- [NBFMtransmit_7, '0', add, '6']
- [NBFMtransmit_7, msg out, pad_sink_0, in]
- [NBFMtransmit_8, '0', add, '7']
- [NBFMtransmit_8, msg out, pad_sink_0, in]
- [add, '0', pad_sink_1, '0']
- [pad_source_0, '0', NBFMreceive_1, '0']
- [pad_source_0, '0', NBFMreceive_2, '0']
- [pad_source_0, '0', NBFMreceive_3, '0']
- [pad_source_0, '0', NBFMreceive_4, '0']
- [pad_source_0, '0', NBFMreceive_5, '0']
- [pad_source_0, '0', NBFMreceive_6, '0']
- [pad_source_0, '0', NBFMreceive_7, '0']
- [pad_source_0, '0', NBFMreceive_8, '0']
- [pad_source_1, out, NBFMreceive_1, msg in]
- [pad_source_1, out, NBFMreceive_2, msg in]
- [pad_source_1, out, NBFMreceive_3, msg in]
- [pad_source_1, out, NBFMreceive_4, msg in]
- [pad_source_1, out, NBFMreceive_5, msg in]
- [pad_source_1, out, NBFMreceive_6, msg in]
- [pad_source_1, out, NBFMreceive_7, msg in]
- [pad_source_1, out, NBFMreceive_8, msg in]
- [pad_source_1, out, NBFMtransmit_1, msg in]
- [pad_source_1, out, NBFMtransmit_2, msg in]
- [pad_source_1, out, NBFMtransmit_3, msg in]
- [pad_source_1, out, NBFMtransmit_4, msg in]
- [pad_source_1, out, NBFMtransmit_5, msg in]
- [pad_source_1, out, NBFMtransmit_6, msg in]
- [pad_source_1, out, NBFMtransmit_7, msg in]
- [pad_source_1, out, NBFMtransmit_8, msg in]

metadata:
  file_format: 1
